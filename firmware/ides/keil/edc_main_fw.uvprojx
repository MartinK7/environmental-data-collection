# Keil uVision project edc_main_fw.uvprojx, settings and files
target edc_main_fw (ARM-GNU)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: edc_main_fw +hex
  group drivers
    ../../drivers/: gpio.c i2c.c rcc.c spi.c systick.c
  group main
    ../../project/: interrupts.c main.c
  group system
    ../../project/system/: syscalls.c system_stm32h7xx.c
  group apps
    ../../project/apps/led/: led_task.c
    ../../project/apps/measure/: measure_task.c
    ../../project/apps/net/: net_task.c
    ../../project/apps/net_interface/: net_interface_task.c
  group libraries/sensors
    ../../libraries/bh1750fvi/bh1750fvi/example/: driver_bh1750fvi_basic.c driver_bh1750fvi_shot.c
    ../../libraries/bh1750fvi/bh1750fvi/interface/: driver_bh1750fvi_interface_template.c
    ../../libraries/bh1750fvi/bh1750fvi/src/: driver_bh1750fvi.c
    ../../libraries/bh1750fvi/porting/: driver_bh1750fvi_interface.c
    ../../libraries/mcp3424/mcp3424-universal-driver/: mcp3424.c
    ../../libraries/mcp3424/porting/: mcp3424_port.c
    ../../libraries/Si1145/porting/: si1145_port.c
    ../../libraries/Si1145/Si1145-universal-driver/: si1145.c
    ../../libraries/wsen_pressure_sensor/porting/: platform.c WSEN_PADS_ADVANCED_EXAMPLE.c
    ../../libraries/wsen_pressure_sensor/Sensors-SDK_STM32/SensorsSDK/WSEN_PADS_2511020213301/: WSEN_PADS_2511020213301.c
software components: Device:Startup 1.9.0
